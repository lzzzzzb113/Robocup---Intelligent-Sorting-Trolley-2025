# Keil uVision project ZZWXC.uvprojx, settings and files
target ZZW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZZWXC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\HARDWARE\ADC;..\HARDWARE\encoder;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\MOTO;..\HARDWARE\PWM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Blance;..\HARDWARE\MPU6050;..\HARDWARE\can;..\HARDWARE\oled;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\usartx;..\HARDWARE\TIMER;..\HARDWARE;..\HARDWARE\oled;..\HARDWARE\Menu;..\HARDWARE\tof;..\HARDWARE\HD;..\HARDWARE\JG;..\KNIFE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_pwr.c stm32f4xx_can.c stm32f4xx_i2c.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c mykey.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWER
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MOTO/: moto.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/usartx/: usartx.c
    ../HARDWARE/Menu/: menu.c
    ../HARDWARE/JG/: hal_drivers.c
    ../HARDWARE/: wit_c_sdk.c
  group Blance
    ../Blance/: system.c PID.c
  group KNIFE
    ../KNIFE/: InitAllinOne.c yzf_area.c yzf_global_sheet.c yz_time_area.c
